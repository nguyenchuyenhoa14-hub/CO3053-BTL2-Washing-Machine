/**
 * @file gfx.c
 * @brief RGB565 framebuffer primitives and 5x7 bitmap font
 */

#include "gfx.h"

uint16_t g_gfx_fb[GFX_WIDTH * GFX_HEIGHT];

typedef struct {
    char ch;
    uint8_t col[5]; /* column-major, bit0 = top row */
} gfx_glyph_t;

static const gfx_glyph_t k_font[] = {
    {' ', {0x00, 0x00, 0x00, 0x00, 0x00}}, {'!', {0x00, 0x00, 0x5F, 0x00, 0x00}},
    {'%', {0x23, 0x13, 0x08, 0x64, 0x62}}, {'(', {0x00, 0x1C, 0x22, 0x41, 0x00}},
    {')', {0x00, 0x41, 0x22, 0x1C, 0x00}}, {'+', {0x08, 0x08, 0x3E, 0x08, 0x08}},
    {'-', {0x08, 0x08, 0x08, 0x08, 0x08}}, {'.', {0x00, 0x60, 0x60, 0x00, 0x00}},
    {'/', {0x20, 0x10, 0x08, 0x04, 0x02}}, {':', {0x00, 0x36, 0x36, 0x00, 0x00}},
    {'<', {0x08, 0x14, 0x22, 0x41, 0x00}}, {'=', {0x14, 0x14, 0x14, 0x14, 0x14}},
    {'>', {0x00, 0x41, 0x22, 0x14, 0x08}}, {'?', {0x02, 0x01, 0x51, 0x09, 0x06}},
    {'_', {0x40, 0x40, 0x40, 0x40, 0x40}},
    {'0', {0x3E, 0x51, 0x49, 0x45, 0x3E}}, {'1', {0x00, 0x42, 0x7F, 0x40, 0x00}},
    {'2', {0x42, 0x61, 0x51, 0x49, 0x46}}, {'3', {0x21, 0x41, 0x45, 0x4B, 0x31}},
    {'4', {0x18, 0x14, 0x12, 0x7F, 0x10}}, {'5', {0x27, 0x45, 0x45, 0x45, 0x39}},
    {'6', {0x3C, 0x4A, 0x49, 0x49, 0x30}}, {'7', {0x01, 0x71, 0x09, 0x05, 0x03}},
    {'8', {0x36, 0x49, 0x49, 0x49, 0x36}}, {'9', {0x06, 0x49, 0x49, 0x29, 0x1E}},
    {'A', {0x7E, 0x11, 0x11, 0x11, 0x7E}}, {'B', {0x7F, 0x49, 0x49, 0x49, 0x36}},
    {'C', {0x3E, 0x41, 0x41, 0x41, 0x22}}, {'D', {0x7F, 0x41, 0x41, 0x22, 0x1C}},
    {'E', {0x7F, 0x49, 0x49, 0x49, 0x41}}, {'F', {0x7F, 0x09, 0x09, 0x09, 0x01}},
    {'G', {0x3E, 0x41, 0x49, 0x49, 0x7A}}, {'H', {0x7F, 0x08, 0x08, 0x08, 0x7F}},
    {'I', {0x00, 0x41, 0x7F, 0x41, 0x00}}, {'J', {0x20, 0x40, 0x41, 0x3F, 0x01}},
    {'K', {0x7F, 0x08, 0x14, 0x22, 0x41}}, {'L', {0x7F, 0x40, 0x40, 0x40, 0x40}},
    {'M', {0x7F, 0x02, 0x0C, 0x02, 0x7F}}, {'N', {0x7F, 0x04, 0x08, 0x10, 0x7F}},
    {'O', {0x3E, 0x41, 0x41, 0x41, 0x3E}}, {'P', {0x7F, 0x09, 0x09, 0x09, 0x06}},
    {'Q', {0x3E, 0x41, 0x51, 0x21, 0x5E}}, {'R', {0x7F, 0x09, 0x19, 0x29, 0x46}},
    {'S', {0x46, 0x49, 0x49, 0x49, 0x31}}, {'T', {0x01, 0x01, 0x7F, 0x01, 0x01}},
    {'U', {0x3F, 0x40, 0x40, 0x40, 0x3F}}, {'V', {0x1F, 0x20, 0x40, 0x20, 0x1F}},
    {'W', {0x3F, 0x40, 0x38, 0x40, 0x3F}}, {'X', {0x63, 0x14, 0x08, 0x14, 0x63}},
    {'Y', {0x07, 0x08, 0x70, 0x08, 0x07}}, {'Z', {0x61, 0x51, 0x49, 0x45, 0x43}}
};

#define FONT_COUNT (sizeof(k_font) / sizeof(k_font[0]))
#define GLYPH_ADV  (6) /* 5 columns + 1 spacing */

static void put_pixel(int x, int y, uint16_t color) {
    if (x >= 0 && x < GFX_WIDTH && y >= 0 && y < GFX_HEIGHT) {
        g_gfx_fb[(y * GFX_WIDTH) + x] = color;
    }
}

void gfx_fill(uint16_t color) {
    for (int i = 0; i < (GFX_WIDTH * GFX_HEIGHT); i++) {
        g_gfx_fb[i] = color;
    }
}

void gfx_rect(int x, int y, int w, int h, uint16_t color) {
    for (int yy = y; yy < (y + h); yy++) {
        for (int xx = x; xx < (x + w); xx++) {
            put_pixel(xx, yy, color);
        }
    }
}

void gfx_frame(int x, int y, int w, int h, uint16_t color) {
    gfx_rect(x, y, w, 1, color);
    gfx_rect(x, y + h - 1, w, 1, color);
    gfx_rect(x, y, 1, h, color);
    gfx_rect(x + w - 1, y, 1, h, color);
}

void gfx_disc(int cx, int cy, int r, uint16_t color) {
    for (int dy = -r; dy <= r; dy++) {
        for (int dx = -r; dx <= r; dx++) {
            if (((dx * dx) + (dy * dy)) <= (r * r)) {
                put_pixel(cx + dx, cy + dy, color);
            }
        }
    }
}

static const uint8_t *find_glyph(char c) {
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    for (unsigned i = 0; i < FONT_COUNT; i++) {
        if (k_font[i].ch == c) {
            return k_font[i].col;
        }
    }
    return k_font[13].col; /* '?' */
}

int gfx_text(int x, int y, const char *s, int scale, uint16_t color) {
    if (s == 0) {
        return x;
    }
    for (; *s != '\0'; s++) {
        const uint8_t *g = find_glyph(*s);
        for (int cx = 0; cx < 5; cx++) {
            for (int cy = 0; cy < 7; cy++) {
                if ((g[cx] & (1U << cy)) != 0U) {
                    gfx_rect(x + (cx * scale), y + (cy * scale), scale, scale, color);
                }
            }
        }
        x += GLYPH_ADV * scale;
    }
    return x;
}

int gfx_text_width(const char *s, int scale) {
    int n = 0;
    while (s != 0 && s[n] != '\0') {
        n++;
    }
    return (n > 0) ? ((n * GLYPH_ADV) - 1) * scale : 0;
}
